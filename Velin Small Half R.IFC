Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-CS02.IFC
Time: 2026-05-01T10:22:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669597223997028; Mass Measure: 21.3383323232257389; Volume Measure: 0.0027356836311828

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669597223997028; Mass Measure: 21.3383323232257389; Volume Measure: 0.0027356836311828

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669597223997028; Mass Measure: 21.3383323232257389; Volume Measure: 0.0027356836311828

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (7)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Author = RevCreatedBy | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision
BASE RETURN^KI-0001-CS02 | BASE RETURN^KI-0001-CS02 | 1.97 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-GS01 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
PLANTER BODY^KI-0001-CS02 | PLANTER BODY^KI-0001-CS02 | 14.90 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-2 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-3 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
TOP RETURN^KI-0001-CS02 | TOP RETURN^KI-0001-CS02 | 0.86 | SOLIDWORKS Custom Properties - Material: MILD STEEL

# IfcElementAssembly, KI-0001-CS02
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669597223997028; Mass Measure: 21.3383323232257389; Volume Measure: 0.0027356836311828

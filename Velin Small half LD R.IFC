Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-CS02.IFC
Time: 2026-05-01T10:21:00+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.81
PSet_Mass_Property - Area Measure: 1.9144763886954024; Mass Measure: 21.8065673669901265; Volume Measure: 0.0027957137649987

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.81
PSet_Mass_Property - Area Measure: 1.9144763886954024; Mass Measure: 21.8065673669901265; Volume Measure: 0.0027957137649987

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.81
PSet_Mass_Property - Area Measure: 1.9144763886954024; Mass Measure: 21.8065673669901265; Volume Measure: 0.0027957137649987

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (8)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Material
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
BASE RETURN^KI-0001-LD-CS02 | BASE RETURN^KI-0001-LD-CS02 | 1.72 | MILD STEEL
TOP RETURN^KI-0001-LD-CS02 | TOP RETURN^KI-0001-LD-CS02 | 0.64 | MILD STEEL
PLANTER BODY^KI-0001-LD-CS02 | PLANTER BODY^KI-0001-LD-CS02 | 2.27 | MILD STEEL
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
Part4^KI-0001-LD-CS02 | Part4^KI-0001-LD-CS02 | 0.86 | MILD STEEL
KI-0000-LD-GS01-2 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
Part3^KI-0001-LD-CS02 | Part3^KI-0001-LD-CS02 | 13.16 | MILD STEEL

# IfcElementAssembly, KI-0001-LD-CS02
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-LD-CS02; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.81
PSet_Mass_Property - Area Measure: 1.9144763886954024; Mass Measure: 21.8065673669901265; Volume Measure: 0.0027957137649987

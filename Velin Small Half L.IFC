Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-CS01.IFC
Time: 2026-05-01T10:22:16+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669316129625422; Mass Measure: 21.3393044446454212; Volume Measure: 0.0027358082621340

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669316129625422; Mass Measure: 21.3393044446454212; Volume Measure: 0.0027358082621340

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669316129625422; Mass Measure: 21.3393044446454212; Volume Measure: 0.0027358082621340

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (7)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Author = RevCreatedBy | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision
PLANTER BODY^KI-0001-CS01 | PLANTER BODY^KI-0001-CS01 | 14.90 | SOLIDWORKS Custom Properties - Material: MILD STEEL
TOP RETURN^KI-0001-CS01 | TOP RETURN^KI-0001-CS01 | 0.86 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-GS01 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
BASE RETURN^KI-0001-CS01 | BASE RETURN^KI-0001-CS01 | 1.97 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-2 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-3 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01

# IfcElementAssembly, KI-0001-CS01
In: default BuildingStorey
SOLIDWORKS Custom Properties - DESCRIPTION: KI-0001-CS01; GA: No; Number: CU - 01 - 300~600; OriginationDate: 31/10/2025; Project Name: Design Projects; RevCreatedBy: J.L; RevCreationDate: 31/10/2025; Revision: M01; WEIGHT: 21.34
PSet_Mass_Property - Area Measure: 1.8669316129625422; Mass Measure: 21.3393044446454212; Volume Measure: 0.0027358082621340
